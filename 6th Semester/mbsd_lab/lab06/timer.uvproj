# Keil uVision project timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.a51 copying_80_bits.a51 adding_4_bites.a51 bcd_addition.a51 setting_bits.a51 mem_addr.a51
